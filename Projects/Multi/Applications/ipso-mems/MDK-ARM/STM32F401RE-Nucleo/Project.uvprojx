# Keil uVision project Project.uvprojx, settings and files
target IKS01A1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ipso-mems-IKS01A1_f401 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: PROJECT_CONF_H=1,X_NUCLEO_IDS01A4,USE_USART2,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6,WITH_UIP,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,COMPILE_SENSORS=1,HARD_CODED_ADDRESS="fdfd::10",UIP_CONF_BUFFER_SIZE=1300,REST_MAX_CHUNK_SIZE=1024,COAP_MAX_HEADER_SIZE=176,REST=REGISTERED_ENGINE_ERBIUM,USE_PUBLIC_LWM2M_SERVER,USE_IKS01A1
  c misc: --C99 --gnu --diag-suppress=188  --diag-suppress=1295
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev\;..\..\..\..\..\..\Middlewares\Third_Party\Contiki;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\loader;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/MEMS
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Example/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Example/User
    ../../Src/: client.c cube_hal_f4.c main.c res-acceleration.c res-humidity.c res-pressure.c res-temperature.c stm32f4xx_hal_msp.c stm32f4xx_it.c res-magneto.c
  group Middlewares/Contiki/apps/er-coap
    ../../../../../../Middlewares/Third_Party/Contiki/apps/er-coap/: er-coap-block1.c er-coap-engine.c er-coap-observe-client.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-separate.c er-coap-transactions.c er-coap.c
  group Middlewares/Contiki/apps/oma-lwm2m
    ../../../../../../Middlewares/Third_Party/Contiki/apps/oma-lwm2m/: lwm2m-device.c lwm2m-engine.c lwm2m-object.c lwm2m-plain-text.c lwm2m-security.c lwm2m-server.c oma-tlv.c oma-tlv-reader.c oma-tlv-writer.c lwm2m-json.c
  group Middlewares/Contiki/apps/rest-engine
    ../../../../../../Middlewares/Third_Party/Contiki/apps/rest-engine/: rest-engine.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/strncasecmp/: strncasecmp.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c link-stats.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c frame802154e-ie.c nordc.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c rpl-nbr-policy.c rpl-ns.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: acceleration-sensor.c button-sensor.c gyroscope-sensor.c humidity-sensor.c leds-arch.c magneto-sensor.c pressure-sensor.c radio-sensor.c temperature-sensor.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c nullradio.c
  group Middlewares/Contiki_STM32_Library/Src
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1.c spirit1-arch.c watchdog.c
  group Middlewares/Contiki/apps/ipso-objects
    ../../../../../../Middlewares/Third_Party/Contiki/apps/ipso-objects/: ipso-acceleration.c ipso-barometer.c ipso-button.c ipso-humidity.c ipso-leds-control.c ipso-objects.c ipso-temperature.c ipso-magneto.c
target IKS01A2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: ipso-mems-IKS01A2_f401 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: PROJECT_CONF_H=1,X_NUCLEO_IDS01A4,USE_USART2,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6,WITH_UIP,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,COMPILE_SENSORS=1,HARD_CODED_ADDRESS="fdfd::10",UIP_CONF_BUFFER_SIZE=1300,REST_MAX_CHUNK_SIZE=1024,COAP_MAX_HEADER_SIZE=176,REST=REGISTERED_ENGINE_ERBIUM,USE_PUBLIC_LWM2M_SERVER,USE_IKS01A2
  c misc: --C99 --gnu --diag-suppress=188  --diag-suppress=1295
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev\;..\..\..\..\..\..\Middlewares\Third_Party\Contiki;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\loader;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip;;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.1
