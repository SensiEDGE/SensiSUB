# IAR project sensi-sub.ewp, settings and files
configuration IKS01A1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PROJECT_CONF_H=1; X_NUCLEO_IDS01A4; USE_USART2; STM32L476xx; USE_SIMSA; USE_HAL_DRIVER; USE_STDPERIPH_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6; WITH_UIP; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6=1; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE=1; COMPILE_SENSORS=1; HARD_CODED_ADDRESS=\"fdfd::10\"; UIP_CONF_BUFFER_SIZE=1300; REST_MAX_CHUNK_SIZE=1024; COAP_MAX_HEADER_SIZE=176; USE_IKS01A1; REST=REGISTERED_ENGINE_ERBIUM; DISABLE_UPDATE_THRESHOLDS
  ICCARM.IExtraOptions: --diag_suppress=Pa089; --diag_suppress=Pe188
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\apds9250; ..\..\..\..\..\..\Drivers\BSP\Components\veml6075; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\lwm2m; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m; ..\..\..\..\..\..\Drivers\BSP\SIMSA
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ipso-mems-SensiSUB_revD.bin
  ILINK.IlinkOutputFile: sensi-sub.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IKS01A2 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: PROJECT_CONF_H=1; X_NUCLEO_IDS01A4; USE_USART2; STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_STDPERIPH_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6; WITH_UIP; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6=1; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE=1; COMPILE_SENSORS=1; HARD_CODED_ADDRESS=\"fdfd::10\"; UIP_CONF_BUFFER_SIZE=1300; REST_MAX_CHUNK_SIZE=1024; COAP_MAX_HEADER_SIZE=176; REST=REGISTERED_ENGINE_ERBIUM; USE_IKS01A2; USE_PUBLIC_LWM2M_SERVER
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\Drivers\BSP\Components\lps25h; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\cpu\arm\stm32; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\lwm2m; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ipso-mems-IKS01A2_f401.bin
  group Drivers/BSP/APDS9250
    ../../../../../../Drivers/BSP/Components/apds9250/: APDS9250_LIGHT_driver.c APDS9250_LIGHT_driver_HL.c
  group Drivers/BSP/MEMS
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/veml6075/: VEML6075_Driver.c VEML6075_Driver_HL.c
  group Drivers/BSP/SIMSA
    ../../../../../../Drivers/BSP/SIMSA/: pwm_buzzer.c simba_lux.h simba_lux_apds9250.c vbat.c
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_audio_l4.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_mic.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c x_nucleo_iks01a1_uv.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/HAL_Driver/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
  group Example/User
    ../../Src/: client.c cube_hal_l4.c main.c res-acceleration.c res-gyroscope.c res-humidity.c res-light.c res-magneto.c res-noise.c res-pressure.c res-temperature.c res-ultraviolet.c stm32l4xx_hal_msp.c stm32l4xx_it.c syscalls.c
  group Middlewares/Contiki/apps/er-coap
    ../../../../../../Middlewares/Third_Party/Contiki/apps/er-coap/: er-coap-block1.c er-coap-engine.c er-coap-observe-client.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-separate.c er-coap-transactions.c er-coap.c
  group Middlewares/Contiki/apps/ipso-objects
    ../../../../../../Middlewares/Third_Party/Contiki/apps/ipso-objects/: ipso-acceleration.c ipso-barometer.c ipso-button.c ipso-digital-output.c ipso-gyroscope.c ipso-humidity.c ipso-leds-control.c ipso-light.c ipso-magneto.c ipso-noise.c ipso-objects.c ipso-temperature.c ipso-ultraviolet.c
  group Middlewares/Contiki/apps/oma-lwm2m
    ../../../../../../Middlewares/Third_Party/Contiki/apps/oma-lwm2m/: lwm2m-device.c lwm2m-engine.c lwm2m-json.c lwm2m-object.c lwm2m-plain-text.c lwm2m-security.c lwm2m-server.c oma-tlv-reader.c oma-tlv-writer.c oma-tlv.c
  group Middlewares/Contiki/apps/rest-engine
    ../../../../../../Middlewares/Third_Party/Contiki/apps/rest-engine/: rest-engine.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c nullradio.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c ringbufindex.c sensors.c settings.c trickle-timer.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: link-stats.c linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/ipv6/multicast
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library/dev
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: acceleration-sensor.c button-sensor.c gyroscope-sensor.c humidity-sensor.c leds-arch.c light-sensor.c magneto-sensor.c microphone-sensor.c pressure-sensor.c radio-sensor.c temperature-sensor.c ultraviolet-sensor.c
  group Middlewares/Contiki_STM32_Library/Src
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1-arch.c spirit1.c watchdog.c
