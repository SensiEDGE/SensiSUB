# IAR project Project.ewp, settings and files
configuration STM32F401RE_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: PROJECT_CONF_H=1; PRESENCE_PERIODIC=1; X_NUCLEO_IDS01A4; USE_PUBLIC_LWM2M_SERVER; X_NUCLEO_6180XA1=1; USE_USART2; STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_STDPERIPH_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6; WITH_UIP; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6=1; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE=1; HARD_CODED_ADDRESS=\"fdfd::10\"; UIP_CONF_BUFFER_SIZE=1300; REST_MAX_CHUNK_SIZE=1024; COAP_MAX_HEADER_SIZE=176; REST=REGISTERED_ENGINE_ERBIUM
  ICCARM.IExtraOptions: --diag_suppress=Pa089; --diag_suppress=Pe188
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-6180XA1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\Drivers\BSP\Components\lps25h; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\cpu\arm\stm32; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\lwm2m; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m; ..\..\..\..\..\..\Drivers\BSP\Components\vl6180x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ipso-flightsense_f401.bin
  ILINK.IlinkOutputFile: ipso-flightsense_f401.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/VL6180x
    ../../../../../../Drivers/BSP/Components/vl6180x/: vl6180x_api.c vl6180x_i2c.c
  group Drivers/BSP/X-NUCLEO-6180XA1
    ../../../../../../Drivers/BSP/X-NUCLEO-6180XA1/: x-nucleo-6180xa1.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: client.c cube_hal_f4.c main.c my_vl6180x.c res-digital-output.c res-presence.c stm32f4xx_hal_msp.c stm32f4xx_it.c syscalls.c
  group Middlewares/Contiki/apps/er-coap
    ../../../../../../Middlewares/Third_Party/Contiki/apps/er-coap/: er-coap-block1.c er-coap-engine.c er-coap-observe-client.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-separate.c er-coap-transactions.c er-coap.c
  group Middlewares/Contiki/apps/ipso-objects
    ../../../../../../Middlewares/Third_Party/Contiki/apps/ipso-objects/: ipso-button.c ipso-digital-output.c ipso-leds-control.c ipso-objects.c ipso-presence.c
  group Middlewares/Contiki/apps/oma-lwm2m
    ../../../../../../Middlewares/Third_Party/Contiki/apps/oma-lwm2m/: lwm2m-device.c lwm2m-engine.c lwm2m-json.c lwm2m-object.c lwm2m-plain-text.c lwm2m-security.c lwm2m-server.c oma-tlv-reader.c oma-tlv-writer.c oma-tlv.c
  group Middlewares/Contiki/apps/rest-engine
    ../../../../../../Middlewares/Third_Party/Contiki/apps/rest-engine/: rest-engine.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c nullradio.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c ringbufindex.c sensors.c settings.c trickle-timer.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: link-stats.c linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/ipv6/multicast
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library/dev
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c presence-sensor.c radio-sensor.c
  group Middlewares/Contiki_STM32_Library/Src
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1-arch.c spirit1.c watchdog.c
